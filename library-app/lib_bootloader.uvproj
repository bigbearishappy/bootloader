# Keil uVision project lib_bootloader.uvproj, settings and files
target lib_boot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lib_bootloader +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o D:\aa.bin E:\16年下半年安排\第7周829-902\bootloader\mybootloader\git\library-version\output\lib_bootloader.axf
  c flags: Optim=1
  c include: .\delay;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./USER/: main.c stm32f10x_it.c queue_loop.c
    ./delay/: delay.c
  group bsp
    ./USER/: BSP.c
  group lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./USER/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Readme
    ./doc/: Readme.txt
